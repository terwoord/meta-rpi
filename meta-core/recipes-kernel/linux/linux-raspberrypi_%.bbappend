FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://no-bluetooth.cfg 		\
			file://no-sound.cfg				\
			file://no-media.cfg				\
			file://no-extra-fs.cfg"


			
# original kernel configuration: 